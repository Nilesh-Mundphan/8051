# Keil uVision project 8051 Master.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: 8051 Master +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\lib;.\modules
  group Source Group 1
    ./: STARTUP.A51
  group lib
    ./lib/: delay.c gpio.c serial.c
  group modules
    ./modules/: lcd.c
  group main
    ./: main.c
